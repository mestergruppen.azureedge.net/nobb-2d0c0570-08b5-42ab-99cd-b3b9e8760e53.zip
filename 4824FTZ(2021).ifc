Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: 0001
Time: 2020-12-18T13:53:06
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20190508_0315(x64) - Exporter 17.4.0.0 - Alternate UI 17.4.0.0
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Fri Dec 18 13:53:06 2020 * Host: Avocado-PC * Database: D:\Jocuri\TEMP\{E40B37A4-EBCF-4739-A3B7-3798A3C38FC0}\ifc * Database version: 5507 * Database creation date: Fri Dec 18 13:53:06 2020 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Fri Dec 18 13:53:06 2020 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Fri Dec 18 13:53:06 2020 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, 0001
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 mm
Other - Category: Project Information; Client Name: Owner; Project Address: Enter address here; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: 0001; Project Status: Project Status

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Other - Category: Project Information; Client Name: Owner; Project Address: Enter address here; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: 0001; Project Status: Project Status

# IfcBuildingStorey, Level 1
LongName: Level 1; Elevation: 0 mm
Other(Type) - Category: Levels; Family Name: Level
Identity Data(Type) - Type Name: 8mm Head
Constraints - Elevation: 0 mm
Dimensions - Computation Height: 0 mm
Identity Data - Building Story: yes; Name: Level 1; Structural: no
Other - Category: Levels; Family: Level: 8mm Head; Family and Type: Level: 8mm Head; Type: Level: 8mm Head; Type Id: Level: 8mm Head
Constraints(Type) - Elevation Base: Project Base Point
Graphics(Type) - Color: 0; Line Pattern: Centre; Line Weight: 1; Symbol: M_Level Head - Circle: M_Level Head - Circle; Symbol at End 1 Default: no; Symbol at End 2 Default: yes

# IfcFlowController: 4824FTZ Washbasin faucet, 9/12 V, Bluetooth, 4824FTZ(2021):4824FTZ Washbasin faucet, 9/12 V, Bluetooth:400659
In: Level 1
Type - PredefinedType: FAUCET; Material: Brass
Type - Dimensions(Type) - InletConnectionSize: 10 mm; NominalDepth: 153.2 mm; NominalHeight: 136 mm; NominalWidth: 65.2 mm
Type - Electrical Engineering(Type) - Bluetooth: 4.x; Electrical Connection: 230 / 9 V; Operating Voltage: 912 V
Type - General(Type) - Author: Convergo AB; BIMObjectName: 4824FTZ(2021); ConvergoRefNr: 0087-2012-0033-FI; ManufacturerName: Oras; ManufacturerURL: http://www.oras.com; NBSDescription: Water supply fittings for wash basins and troughs; NBSReference: 45-35-70/371; ProductInformation: Kitchen faucet with high spout.; Revision: n/a; Uniclass2: Pr_40_30_96_78; Uniclass2015Description: Shower manual water supply sets; Uniclass2015Reference: Pr_40_20_87_78; Version: 1; VersionDate: 15/12/2020
Type - Green Building Properties(Type) - Customs Code: 84818011; EAN Number: 6414150097096; EMC Directive: 2014/53/EU; EN Standard: EN 15091; LVI Number: 6110342; VVS Number: 704214604
Type - Identity Data(Type) - 2D/3D/BIM Files URL: http://static.oras.com/bim/4824FTZ; Catalog Drawing URL: http://static.oras.com/catdrw/4824FTZ; Class: Touchless;Bluetooth®;Plug transformer; Dimension Drawing URL: http://static.oras.com/dimdrw/4824FTZ; FDV Document URL: http://www.oras.com/datasheet/4824FTZ/en/fdv; Flow Drawing URL: http://static.oras.com/flowchart/4824FTZ; Group: Washbasin faucets; Manufacturer: Oras; Market: INT;FIN;NOR;SWE;DNK;POL;RUS;EST;LTU;LVA;UKR; Model: 4824FTZ Washbasin faucet, 9/12 V, Bluetooth; Name_en: 4824FTZ Washbasin faucet, 9/12 V, Bluetooth; OmniClass Number: 23.45.55.00; OmniClass Title: Sanitary Faucets, Wastes; Package external Dimensions: 290 x 210 x 90; Product Code: 4824FTZ; Product Datasheet: http://www.oras.com/datasheet/4824FTZ/en; Product Family: Oras Stela; Product Image URL: http://static.oras.com/image/4824FTZ; Product URL: http://static.oras.com/4824FTZ; Technical DataSheet URL: http://www.oras.com/datasheet/4824FTZ/en; Type Name: 4824FTZ Washbasin faucet, 9/12 V, Bluetooth
Type - Materials and Finishes(Type) - FaucetMainMaterial: Brass
Type - Mechanical(Type) - Advanced Features: DZR brass;Adjustable settings (via bluetooth); Aerator: CACHÉ® integrated aerator;Pressure controlled aerator;Swivel aerator; Afterflow Period: 3120; Automatic Flush: off (off/1-120 h); Automatic Flush Period: 30 s (1-1800 s); Connection: FlexibleInletPipes; Connection Size: G3/8; Flow Rate At 300kPa With Flow Controller: 0.00353147 m3/s; Installation and Maintenance: http://static.oras.com/manual/4824FTZ; Installation Type: Deck mounted; Max. Hot Water Supply: 70 kg/K/s3; Max Flow Period: 211800; Mounting Holes: 1MountingHole; Noise Class: I (ISO 3822); Not Included: WithoutPopupWaste; Protection Class: IP 55 / transformer IP 20; Spare Parts: http://static.oras.com/sp/4824FTZ; Spout Type: Fixed spout
Type - Other(Type) - Category: Plumbing Fixtures; AccessibilityPerformance: n/a; AssetType: Fixed; Brand: Oras; CodePerformance: n/a; Color: Chrome; Constituents: n/a; DurationUnit: Year; ExpectedLife: n/a; Family Name: 4824FTZ(2021); Features: Touchless;Bluetooth®;Plug transformer; Finish: Polished; Grade: n/a; Material: Brass; ModelNumber: n/a; ModelReference: 4824FTZ; Name: 4824FTZ Washbasin faucet, 9/12 V, Bluetooth; ReplacementCost: n/a; Shape: Sculptured; Size: 65x155x135 mm; SustainabilityPerformance: n/a; WarrantyDescription: http://warranty.oras.com; WarrantyDurationLabor: n/a; WarrantyDurationParts: n/a; WarrantyDurationUnit: Year; WarrantyGuarantorLabor: n/a; WarrantyGuarantorParts: n/a
Pset_ManufacturerTypeInformation - ModelReference: 4824FTZ; Manufacturer: Oras
Pset_DistributionFlowElementCommon - Reference: 4824FTZ Washbasin faucet, 9/12 V, Bluetooth
Constraints - DefaultElevation: 900 mm; Host: Level : Level 1; Level: Level: Level 1; Offset: 0 mm
Dimensions - Area: 0.0407627 m2; Volume: 0.00136132 m3
Identity Data - Mark: 2
Mechanical - System Classification: Domestic Hot Water,Domestic Cold Water
Other - AssetIdentifier: n/a; Barcode: n/a; Category: Plumbing Fixtures; Family: 4824FTZ(2021): 4824FTZ Washbasin faucet, 9/12 V, Bluetooth; Family and Type: 4824FTZ(2021): 4824FTZ Washbasin faucet, 9/12 V, Bluetooth; InstallationDate: n/a; SerialNumber: n/a; TagNumber: n/a; Type: 4824FTZ(2021): 4824FTZ Washbasin faucet, 9/12 V, Bluetooth; Type Id: 4824FTZ(2021): 4824FTZ Washbasin faucet, 9/12 V, Bluetooth; WarrantyStartDate: n/a
Phasing - Phase Created: New Construction
